File: Hardware/ETH1LCR3/ETH1LCR3.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: PCB layout
Other:
- moved on the sheet: HS101
